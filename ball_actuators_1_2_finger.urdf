Commit message: ball urdf

File: ball_actuators_1_2_finger.urdf (robot description, URDF)
Before this commit: robot spherical_actuators, 1 links, 0 joints
Links:
- removed link sphere_0
- added link sphere_link, mass 0.1; collision sphere radius=0.01; visual sphere radius=0.01
