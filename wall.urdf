Commit message: Fix urdf

File: wall.urdf (robot description, URDF)
Before this commit: robot wall, 1 links, 0 joints
Links:
- link wall: geometry visual box size=0.5 0.5 0.001
